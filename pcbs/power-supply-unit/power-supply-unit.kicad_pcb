# Repository GaryBlackbourne/raspberry-robot

## KiCad design pcbs/power-supply-unit/power-supply-unit.kicad_pcb

Parts:
C1, C2: 100u; C_Elec_6.3x7.7
C3, C4: 1000u; C_Elec_10x10.2
C5: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C6: 47u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1, D2: D_Schottky; D_DO-201AD_P15.24mm_Horizontal
J1: BMS_OUTPUT; PinHeader_1x02_P2.54mm_Horizontal
J2: PWR_CONN_RASPI; PinHeader_1x02_P2.54mm_Horizontal
J3: PWR_CONN_CTRL; PinHeader_1x03_P2.54mm_Horizontal
L1, L2: 100u; L_Fastron_PISR_Handsoldering
R1: 20k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2, R4: 5k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3: 15k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U1, U2: LM2576S-ADJ; TO-263-5_TabPin3
U3: AMS1117-3.3; SOT-223-3_TabPin2

Connections:
+3V3: C6.1, J3.2, U3.2 (VO)
+5V: C4.1, C5.1, J2.1, L2.2, R3.1, U3.3 (VI)
+6V: C3.1, J3.1, L1.2, R1.1
+12V: C1.1, C2.1, J1.1, U1.1 (VIN), U2.1 (VIN)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, D1.2 (A), D2.2 (A), J1.2, J2.2, J3.3, R2.2, R4.2, U1.3 (GND), U1.5 (~ON/OFF), U2.3 (GND), U2.5 (~ON/OFF), U3.1 (GND)
unnamed: D1.1 (K), L1.1, U1.2 (OUT)
unnamed: D2.1 (K), L2.1, U2.2 (OUT)
unnamed: R1.2, R2.1, U1.4 (FB)
unnamed: R3.2, R4.1, U2.4 (FB)

Notes on the sheet:
GND
PWR connector to control module
PWR connector to raspberry pi
Buck converter 6V
BMS output
Regulated 3V3 supply
12V
Buck converter 5V
BMS
Battery Management System will handle 3 battery cells and provide approximately 12V input for the power supply board

Board: 2 copper layers, 37.5 x 86.0 mm, 24 parts (0 on the bottom side), 9 nets.

Other parts of the board:
REF01, REF02, REF03, REF03#2: MountingHole_2.5mm

## KiCad design pcbs/movement-control/movement-control.kicad_pcb

Parts:
A1: TMC2208_module; Pololu_Breakout-16_15.2x20.3mm
C1, C3, C4, C6, C7, C9, C12: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2, C5, C10, C11: 47u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C8: 1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J1: CONN_SERVO_RIGHT; PinHeader_1x06_P2.54mm_Horizontal
J2: CONN_SERVO_LEFT; PinHeader_1x06_P2.54mm_Horizontal
J4: SENSOR_CONNECTOR_1; PinHeader_1x05_P2.54mm_Horizontal
J5: RASPBERRY_CONNECTOR; PinHeader_1x03_P2.54mm_Horizontal
J6: SENSOR_CONNECTOR_2; PinHeader_1x05_P2.54mm_Horizontal
J7: PWR_input; PinHeader_1x03_P2.54mm_Horizontal
J8: SENSOR_CONNECTOR_3; PinHeader_1x05_P2.54mm_Horizontal
J9: SENSOR_CONNECTOR_4; PinHeader_1x05_P2.54mm_Horizontal
J10: DEBUG_UART; PinHeader_1x04_P2.54mm_Vertical
J11: Stepper_motor_out; PinHeader_1x04_P2.54mm_Horizontal
J12: SWD_CONNECTOR; PinHeader_2x05_P2.54mm_Vertical
R1, R2, R3, R4, R7, R8: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R5, R11: 100k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R6, R13: 100; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R9: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R10, R12, R14, R15: 4.7k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
SW1: SW_RST; SW_Push_1P1T_NO_6x6mm_H9.5mm
SW2: SW_BTN; SW_Push_1P1T_NO_6x6mm_H9.5mm
U1, U2: BD6220F-E2; SOP-8_3.9x4.9mm_P1.27mm
U3: STM32F103C8Tx; LQFP-48_7x7mm_P0.5mm

Connections:
+3V3: A1.2 (VDD), A1.10 (MS1), A1.11 (MS2), C1.1, C3.1, C6.1, C7.1, C8.1, C12.1, J1.2, J2.2, J4.1, J6.1, J7.2, J8.1, J9.1, J10.1, R5.1, R10.1, R11.1, R12.1, R14.1, R15.1, U1.6 (VREF), U2.6 (VREF), U3.1 (VBAT), U3.9 (VDDA), U3.24 (VDD), U3.36 (VDD), U3.48 (VDD)
+6V: A1.8 (VMOT), C2.1, C5.1, C10.1, C11.1, J7.1, U1.2 (VCC), U1.3 (VCC), U2.2 (VCC), U2.3 (VCC)
/1A: A1.4 (1A), J11.4
/1B: A1.3 (1B), J11.2
/2A: A1.5 (2A), J11.3
/2B: A1.6 (2B), J11.1
/BOOT0: R7.2, U3.44 (BOOT0)
/BTN_0: C9.1, R13.2, U3.15 (PA5)
/ENCODER_LEFT_A_PHASE: J2.3, U3.10 (PA0)
/ENCODER_LEFT_B_PHASE: J2.4, U3.11 (PA1)
/ENCODER_RIGHT_A_PHASE: J1.3, U3.16 (PA6)
/ENCODER_RIGHT_B_PHASE: J1.4, U3.17 (PA7)
/I2C1_SCL: J4.4, J6.4, J8.4, J9.4, R10.2, U3.45 (PB8)
/I2C1_SDA: J4.3, J6.3, J8.3, J9.3, R12.2, U3.46 (PB9)
/I2C2_SCL: J5.2, R14.2, U3.21 (PB10)
/I2C2_SDA: J5.1, R15.2, U3.22 (PB11)
/LED_0: R9.1, U3.14 (PA4)
/NRST: C4.1, J12.9, R6.2, U3.7 (NRST)
/SERVO_CTRL_LEFT_FORWARD: R3.1, U2.4 (FIN), U3.31 (PA10)
/SERVO_CTRL_LEFT_OUT_1: J2.1, U2.1 (OUT1)
/SERVO_CTRL_LEFT_OUT_2: J2.6, U2.7 (OUT2)
/SERVO_CTRL_LEFT_REVERSE: R4.1, U2.5 (RIN), U3.32 (PA11)
/SERVO_CTRL_RIGHT_FORWARD: R1.1, U1.4 (FIN), U3.29 (PA8)
/SERVO_CTRL_RIGHT_OUT_1: J1.1, U1.1 (OUT1)
/SERVO_CTRL_RIGHT_OUT_2: J1.6, U1.7 (OUT2)
/SERVO_CTRL_RIGHT_REVERSE: R2.1, U1.5 (RIN), U3.30 (PA9)
/SHUT_1: J4.5, U3.25 (PB12)
/SHUT_2: J6.5, U3.26 (PB13)
/SHUT_3: J8.5, U3.27 (PB14)
/SHUT_4: J9.5, U3.28 (PB15)
/SWCLK: J12.3, U3.37 (PA14)
/SWDIO: J12.1, U3.34 (PA13)
/SWO: J12.7, U3.39 (PB3)
/TMC_DIR: A1.16 (DIR), U3.20 (PB2)
/TMC_PDN_UART: A1.12 (PDN_UART), A1.13 (PDN_UART), U3.42 (PB6)
/TMC_STEP: A1.15 (STEP), U3.19 (PB1)
/UART_RX: J10.3, U3.13 (PA3)
/UART_TX: J10.4, U3.12 (PA2)
GND: A1.1 (GND), A1.7 (GND), A1.14 (CLK), C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, D1.1 (K), J1.5, J2.5, J4.2, J5.3, J6.2, J7.3, J8.2, J9.2, J10.2, J12.2, J12.4, J12.6, J12.8, J12.10, R1.2, R2.2, R3.2, R4.2, R7.1, R8.1, SW1.1, SW2.1, U1.8 (GND), U2.8 (GND), U3.8 (VSSA), U3.23 (VSS), U3.35 (VSS), U3.47 (VSS)
unnamed: A1.9 (~ENABLE), R8.2
unnamed: D1.2 (A), R9.2
unnamed: R5.2, R6.1, SW1.2
unnamed: R11.2, R13.1, SW2.2

Notes on the sheet:
BOOT
MANUAL RESET
STM32 microcontroller
Sepper motor capacitors
I2C BUS SENSORS
MCU
Steper motor out
Servo control stabilizer resistors
Servo drive capacitors
Servo Motor
Raspberry Connector
3x VDD capacitors + VDDA capacitor
Basic Peripherals
Stepper motor drive
SW debug connector
MCU capacitor
Servo connectors
Encoder PWR
Stepper motor
Servo motor drivers
I2C BUS RASPBERRY
SENSOR CONNECTORS
PWR input

Board: 4 copper layers, 91.4 x 63.5 mm, 49 parts (0 on the bottom side), 43 nets.

Other parts of the board:
REF01, REF02, REF03, REF04: MountingHole_2.5mm

## Code that names these connections

File firmware/modules/main/inc/main.h:

#ifndef __MAIN_H
#define __MAIN_H

#include "stm32f1xx_hal.h"

void HAL_TIM_MspPostInit(TIM_HandleTypeDef *htim);

void Error_Handler(void);

#define ENCODER_LEFT_A_Pin GPIO_PIN_0
#define ENCODER_LEFT_A_GPIO_Port GPIOA
#define ENCODER_LEFT_B_Pin GPIO_PIN_1
#define ENCODER_LEFT_B_GPIO_Port GPIOA
#define LED_Pin GPIO_PIN_4
#define LED_GPIO_Port GPIOA
#define BTN_Pin GPIO_PIN_5
#define BTN_GPIO_Port GPIOA
#define ENCODER_RIGHT_A_Pin GPIO_PIN_6
#define ENCODER_RIGHT_A_GPIO_Port GPIOA
#define ENCODER_RIGHT_B_Pin GPIO_PIN_7
#define ENCODER_RIGHT_B_GPIO_Port GPIOA
#define SHUT_1_Pin GPIO_PIN_12
#define SHUT_1_GPIO_Port GPIOB
#define SHUT_2_Pin GPIO_PIN_13
#define SHUT_2_GPIO_Port GPIOB
#define SHUT_3_Pin GPIO_PIN_14
#define SHUT_3_GPIO_Port GPIOB
#define SHUT_4_Pin GPIO_PIN_15
#define SHUT_4_GPIO_Port GPIOB
#define SERVO_RIGHT_FORWARD_Pin GPIO_PIN_8
#define SERVO_RIGHT_FORWARD_GPIO_Port GPIOA
#define SERVO_RIGHT_REVERSE_Pin GPIO_PIN_9
#define SERVO_RIGHT_REVERSE_GPIO_Port GPIOA
#define SERVO_LEFT_FORWARD_Pin GPIO_PIN_10
#define SERVO_LEFT_FORWARD_GPIO_Port GPIOA
#define SERVO_LEFT_REVERSE_Pin GPIO_PIN_11
#define SERVO_LEFT_REVERSE_GPIO_Port GPIOA

#define SERVO_RIGHT_FORWARD_CHANNEL TIM_CHANNEL_1
#define SERVO_RIGHT_REVERSE_CHANNEL TIM_CHANNEL_2
#define SERVO_LEFT_FORWARD_CHANNEL TIM_CHANNEL_3
#define SERVO_LEFT_REVERSE_CHANNEL TIM_CHANNEL_4

#endif /* __MAIN_H */

## Commit log

2022-03-10 Add notes to gitignore
2022-03-10 Initiate kicad project
2022-03-11 Add motor driver to partlist
2022-03-11 Add PCB design for control module
2022-03-11 Reposition schematic elements
2022-03-11 Add capacitor to stepper motor driver, and add pdf schematic
2022-03-18 Apend parts list, and finish schematics
2022-03-18 Created power supply project
2022-03-18 Add power supply module schematic to project
2022-03-25 Add connectors and organize PWR supply schematic
2022-03-25 Update gitignore
2022-03-25 Update gitignore, fix unnecessary file in repo
2022-03-25 Create basic layout design for the power supply module
2022-03-26 Add power supply pcb layout
2022-04-28 Add resistor footprints to ctrl board
2022-04-28 Add footprints to ctrl board
2022-04-30 Add auto saved files to gitignore
    Fix motor driver power inputs.
    Add PWR_FLAGs to 3V3, 6V and GND
2022-04-30 Fix servo driver capacitors
    connected to 3v3 instead of 6V
2022-04-30 Fix wrong name for servo motor connectors
2022-05-04 Modify SWD connector schematic, and add correct footprints
2022-05-04 Fix connected power and gnd
    Connected power and gnd fixed in motor output power labels. Also PWR flags were removed, and power outputs were created at PWR_CONNECTOR
2022-05-04 Fix motor signal bug, and add footprint to movement-control
2022-05-04 Add mounting holes to PSU
2022-05-04 Add pdf documentation, to schemas/pdf
2022-05-23 Add sketch for presentation
    This commit does nothing with the project itself, only adds
    presentation, that I had to do.
2022-05-25 Add documentation in .md and .pdf format
2022-09-28 Add initial firmware to project
2022-09-28 Remove README (left from template). Add basic FreeRTOS functions
2022-09-29 Add project management to gitignore
2022-10-07 Redesign PWR supply to match real part footprints
2022-10-07 Removed truncation from make output
2022-10-07 Add basic FreeRTOS architecture, and working drive functions for usart
2022-10-08 Fix small errors, add more stitching vias
2022-11-03 Rework firmware structure
    - several functions are now placed in different files to make it easy to
    find stuff.
    - usart communication is in working condition, can acknowledge commands
    and use notifications to turn led on and off.
    - fix a bug in clock management function, where the exact same bytes
    were ANDed, and thus made incorrect, but working code.
2022-11-03 FIRMWARE: Fix incorrect code in clock selection
    Rewrite RCC CFGR settings to be more readable
2022-11-17 Minor redesign of vias on pwr supply
2022-11-17 Add i2c basic functions to project
2022-11-17 Remove compile_commands.json because it can be generated by `bear`
2022-11-17 Enabled alternate function and separated GPIO setup management into one function
2022-11-17 Add proper pwm functionality with timers
2022-11-17 Add test motor task for pwm testing
2022-11-17 Add i2c interrupt function
2022-11-17 Fix small inaccuracy in led setup
2022-11-17 Actualize main.c file with testing and comments
2022-12-15 Add documentation
2023-08-09 Refactor projects documentation
    Documents are now separated into 'doc' and 'resources' directories.
    'Doc' contains documentation for the project, while 'resources'
    contains useful docs, that i have collected or created to aid me in development.
2023-08-09 Fixed missing documentation
2023-08-09 Added pwr supply parts list
2023-08-10 Fix mounting hole position inaccuracy with pwr-supply
2023-08-11 Add mechanical drawings and datasheet for battery nest
2023-08-11 Format link for range sensor
2023-08-11 Add datasheet, and remove gitignore entry
2023-09-11 Added battery link
2024-03-22 Change build system for the firmware and updated gitignores
2024-03-23 Set some project specific properties
2024-03-23 Add mcu includes as dependency in make and remove unnecessary files
2024-03-25 Work on building scripts
2024-03-25 Fix bugs, and make build system work
2024-03-26 Move mapfile output to output directory
2024-03-26 Restructure bsp module for better readability
2024-03-26 Fix build script
2024-03-27 Add HAL layer, create blink project with freeRTOS and hal
2024-03-28 Remove old bsp layer, and add new task with uart
2024-03-29 Remove build artifacts from hal module
2024-04-01 Add generated hal code, and FreeRTOS blink
2024-04-02 Separate functions into different files, and organize main module
2024-04-02 Add struct for actual and target speed
2024-04-02 Comment ranging sensor parts
2024-04-06 Add uart interrupt reception functionality
2024-04-06 Add comments and define for command chain length
2024-04-11 Add firmware block diagram
2024-04-11 Add separate tasks for comms and organize globals together
2024-04-11 Add command parser, and robot state
2024-04-12 Add debud and optimalization flags to build
2024-04-12 Add command parsing capability and fixed interrupt queuing
2024-04-12 Add response functions
2024-04-12 Updated rx processor task
2024-04-15 Add gdb start script
2024-04-15 Add DMA transmit functionality
2024-04-15 Add transmit task, dma sync and fix task creation
2024-04-16 Add gdb and openocd scripts
2024-04-16 Add pwm test code to main
2024-04-17 Add controller diagram to drawio file
2024-04-17 Add motor control as a task to the system with encoder and pwm generation
2024-04-18 Adjust USART and DMA IRQ priorities
2024-04-18 Rename enums for clarity, reorder priorities for tasks
2024-04-18 Add motor controlling functions
2024-04-28 Add pid functions
    The PID implementation was taken from a repository:
    https://github.com/pms67/PID.git
2024-04-29 Add motor parameters and defines
2024-04-29 Add motor control task and functions
2024-04-29 Fix missing function declaration
2024-04-29 Add VL53L1CB ultra lite driver, and platform code
2024-05-01 Add sensor functionality
    Add sensor reader task
    Add sensor handler functions
    Fix pinout for i2c
    Add driver tweaks
2024-05-01 Fix sensor address function and remove binaries form vc
2024-05-01 Add working 4 sensor driver
2024-05-02 Sanitize robot internals struct, and add range measurement storage
2024-05-02 Fix build errors, add motor symmetry
2024-05-02 Fix build error
2024-05-03 Add helper math functions
2024-05-03 Add synchronisation objects
2024-05-03 Add pid frame, and command execution functions
2024-05-03 Add implementation for robot internals
2024-05-09 Extend incorrect buffer size, and tidy repository
2024-05-09 Synchronise processes, and fix bugs
2024-05-16 Add timeout for motor controll
2024-05-17 Fix sensor directions and speed calculation
